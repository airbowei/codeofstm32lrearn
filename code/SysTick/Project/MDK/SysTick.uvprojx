# Keil uVision project SysTick.uvprojx, settings and files
target SysTick (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F003F6 Geehy
  pack: Geehy.APM32F00x_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SysTick +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Include;..\..\..\Board;..\..\..\Library\APM32F00x_StdPeriphDriver\inc;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Geehy\APM32F00x\Include;..\MDK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000008 size 0x1000
  group CMSIS
    ../../../Library/Device/Geehy/APM32F00x/Source/: system_apm32f00x.c
    ../../../Library/Device/Geehy/APM32F00x/Source/ARM/: startup_apm32f0xx.s
  group StdPeriphDriver
    ../../../Library/APM32F00x_StdPeriphDriver/src/: apm32f00x_gpio.c apm32f00x_rcm.c apm32f00x_eint.c apm32f00x_adc.c apm32f00x_buzzer.c apm32f00x_fmc.c apm32f00x_i2c.c apm32f00x_iwdt.c apm32f00x_misc.c apm32f00x_spi.c apm32f00x_tmr1.c apm32f00x_tmr2.c apm32f00x_tmr4.c apm32f00x_usart.c apm32f00x_wupt.c apm32f00x_wwdt.c
  group Board
    ../../../Board/: Board.c
  group Application
    ../../Source/: main.c apm32f00x_int.c power_manage.c power_manage.h adc.c error.c gpio.c timer.c uart.c adc.h error.h gpio.h timer.h uart.h ram.c ram.h security_manage.c security_manage.h
